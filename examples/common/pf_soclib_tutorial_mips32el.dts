/dts-v1/;

/ {
	model = "MutekH_SoCLib_Tutorial";
	compatible = "MutekH_SoCLib_Tutorial";
	#address-cells = <1>;
	#size-cells = <1>;

	cpus {
		#address-cells = <1>;
		#size-cells = <0>;

m4_forloop(i, 0, CONFIG_CPU_MAXCOUNT-1, `

		Mips,32@i {
			name = "Mips,32";
			device_type = "cpu";
			reg = <i>;
			icudev_type = "cpu:mips";
			ipi = <&{/xicu@0/out@i} i>;
		};
')
	};

	tty@0 {
	    device_type = "soclib:tty";
		tty_count = <1>;
		reg = <0xd0200000 0x10>;
		irq = <&{/xicu@0/out@0} 0>;
	};

	block@0 {
	    device_type = "soclib:block_device";
		reg = <0xd1200000 0x20>;
		irq = <&{/xicu@0/out@0} 1>;
	};

	xicu@0 {
	    device_type = "soclib:xicu:root";
		input_lines = <2>;
		ipis = <8>;
		timers = <1>;
		reg = <0xd2200000 0x1000>;

m4_forloop(i, 0, CONFIG_CPU_MAXCOUNT-1, `

	    	out@i {
	    	    device_type = "soclib:xicu:filter";
	    	    parent = &{/xicu@0};
	    		output_line = <i>;
	    		irq = <&{/cpus/Mips,32@i} 0>;
	    	};
')
	};

	memory@0 {
		device_type = "memory";
		cached;
		memreg: reg = <0x7f000000 0x01000000>;
	};

	chosen {
		console = &{/tty@0};
//        timer = &{/xicu@0};
	};

};
